!Agilent Technologies,E5071C,MY46418240,A.11.23
!Date: Mon Dec 07 11:48:10 2020
!Data & Calibration Information:
!Freq	S11:SOLT2(ON)	S21:SOLT2(ON)	S12:SOLT2(ON)	S22:SOLT2(ON)
!PortZ  Port1:50+j0  Port2:50+j0
!Above PortZ is port z conversion or system Z0 setting when saving the data.
!When reading, reference impedance value at option line is always used.
# Hz S dB R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 300 kHz to 12 GHz, reference 50 ohm
!   highest |S21| = -22.72 dB at 300 kHz (marker M1); lowest = -39.8 dB at 255.3 MHz (marker M2)
!   lowest |S11| = -1.5 dB at 11.15 GHz (marker M3), VSWR 11.60, Z = 9.71 - j55.5 ohm
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -1.9 to -0.2 dB; largest |S21 - S12| = 0.0054
!   the Smith chart shows 9.345 GHz to 12 GHz only
!   S11 on the Smith chart (normalised r, x): 9.345 GHz: 0.08, -0.06; 9.885 GHz: 0.12, +0.74; 10.43 GHz: 1.39, +3.74; 10.95 GHz: 0.41, -1.93; 11.48 GHz: 0.09, -0.43; 12 GHz: 0.07, +0.28
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 300 kHz  -0.5  -22.7  -22.7  -0.6
! 75.3 MHz  -0.2  -39.3  -39.2  -0.2
! 255.3 MHz  -0.3  -39.8  -39.8  -0.3
! 660.3 MHz  -0.3  -38.8  -38.8  -0.3
! 2.01 GHz  -0.4  -33.2  -33.2  -0.4
! 4.005 GHz  -0.7  -28.5  -28.6  -0.7
! 4.575 GHz  -0.7  -27.7  -27.8  -0.7
! 6 GHz  -0.8  -27.5  -27.6  -0.8
! 7.245 GHz  -0.9  -26.8  -26.9  -0.9
! 8.01 GHz  -1.1  -27.7  -27.7  -0.9
! 8.325 GHz  -1.2  -29.6  -29.6  -1.0
! 8.895 GHz  -1.3  -34.1  -33.9  -1.1
! 9.03 GHz  -1.3  -34.0  -33.9  -1.1
! 9.345 GHz  -1.3  -32.0  -31.7  -1.2
! 9.885 GHz  -1.4  -29.1  -29.0  -1.4
! 10.01 GHz  -1.4  -28.0  -27.8  -1.4
! 10.43 GHz  -1.4  -26.0  -25.6  -1.6
! 10.67 GHz  -1.4  -24.6  -24.2  -1.7
! 10.95 GHz  -1.5  -24.3  -23.9  -1.8
! 11.15 GHz  -1.5  -25.7  -25.4  -1.9
! 11.48 GHz  -1.3  -27.5  -27.3  -1.9
! 12 GHz  -1.1  -27.1  -27.1  -1.5
